# IAR project 007ClockAlarm.ewp, settings and files
configuration 007ClockAlarm (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401RE ST STM32F401RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F401xE
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; ..\qm; ..\Third_party\qp\qpc\src\qf; ..\Third_party\qp\qpc\ports\arm-cm\qv\iar; ..\Third_party\qp\qpc\ports\arm-cm\config; ..\Third_party\qp\qpc\include; ..\qm; ..\lib
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: 007ClockAlarm.hex
  ILINK.IlinkOutputFile: 007ClockAlarm.out
  ILINK.IlinkIcfFile: stm32f401xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f401xe.s
  group Application/User/Core
    ../Core/Src/: gpio.c i2c.c main.c stm32f4xx_hal_msp.c stm32f4xx_it.c tim.c usart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group lib
    ../lib/: LCD_I2C_lib.c LCD_I2C_lib.h
  group qm
    ../qm/: ClockAlarm_SM.c ClockAlarm_SM.h
  group qpc/include
    ../Third_party/qp/qpc/include/: qequeue.h qk.h qmpool.h qp.h qp_pkg.h qpc.h qs_dummy.h qsafe.h qstamp.h qv.h
  group qpc/port/arm-cm/config
    ../Third_party/qp/qpc/ports/arm-cm/config/: qp_config.h
  group qpc/port/arm-cm/qv/iar
    ../Third_party/qp/qpc/ports/arm-cm/qv/iar/: qp_port.h qs_port.h qv_port.c
  group qpc/src/qf
    ../Third_party/qp/qpc/src/qf/: qep_hsm.c qep_msm.c qf_act.c qf_actq.c qf_defer.c qf_dyn.c qf_mem.c qf_ps.c qf_qact.c qf_qeq.c qf_qmact.c qf_time.c
